SUMMARY = "Actor model library (Mopidy core dependency)"
HOMEPAGE = "https://pypi.org/project/pykka/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

PYPI_PACKAGE = "pykka"

SRC_URI[sha256sum] = "54fcfb9ed5ef92eb98bf9961cfdefbc73ddfbf24060e319d50fde6ec66d00d8a"

inherit pypi python_hatchling
